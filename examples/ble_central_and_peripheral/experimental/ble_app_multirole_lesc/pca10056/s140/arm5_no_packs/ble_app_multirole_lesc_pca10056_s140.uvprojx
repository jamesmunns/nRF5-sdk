# Keil uVision project ble_app_multirole_lesc_pca10056_s140.uvprojx, settings and files
target nrf52840_xxaa (ARM-ADS)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.12.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52840_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BLE_STACK_SUPPORT_REQD BOARD_PCA10056 CONFIG_GPIO_AS_PINRESET NRF52840_XXAA NRF_SD_BLE_API_VERSION=5 S140 SOFTDEVICE_PRESENT SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION SWI_DISABLE0 __HEAP_SIZE=0
  c misc: --reduce_paths
  c include: ..\..\..\config;..\..\..\..\..\..\..\components;..\..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\..\components\ble\ble_db_discovery;..\..\..\..\..\..\..\components\ble\ble_dtm;..\..\..\..\..\..\..\components\ble\ble_racp;..\..\..\..\..\..\..\components\ble\ble_services\ble_ancs_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_ans_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\..\..\..\components\ble\ble_services\ble_bas_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_cscs;..\..\..\..\..\..\..\components\ble\ble_services\ble_cts_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_dfu;..\..\..\..\..\..\..\components\ble\ble_services\ble_dis;..\..\..\..\..\..\..\components\ble\ble_services\ble_gls;..\..\..\..\..\..\..\components\ble\ble_services\ble_hids;..\..\..\..\..\..\..\components\ble\ble_services\ble_hrs;..\..\..\..\..\..\..\components\ble\ble_services\ble_hrs_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_hts;..\..\..\..\..\..\..\components\ble\ble_services\ble_ias;..\..\..\..\..\..\..\components\ble\ble_services\ble_ias_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_lbs;..\..\..\..\..\..\..\components\ble\ble_services\ble_lbs_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_lls;..\..\..\..\..\..\..\components\ble\ble_services\ble_nus;..\..\..\..\..\..\..\components\ble\ble_services\ble_nus_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_rscs;..\..\..\..\..\..\..\components\ble\ble_services\ble_rscs_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_tps;..\..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\..\components\ble\nrf_ble_gatt;..\..\..\..\..\..\..\components\ble\nrf_ble_qwr;..\..\..\..\..\..\..\components\ble\peer_manager;..\..\..\..\..\..\..\components\boards;..\..\..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\..\components\drivers_nrf\comp;..\..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\..\components\drivers_nrf\i2s;..\..\..\..\..\..\..\components\drivers_nrf\lpcomp;..\..\..\..\..\..\..\components\drivers_nrf\pdm;..\..\..\..\..\..\..\components\drivers_nrf\power;..\..\..\..\..\..\..\components\drivers_nrf\ppi;..\..\..\..\..\..\..\components\drivers_nrf\pwm;..\..\..\..\..\..\..\components\drivers_nrf\qdec;..\..\..\..\..\..\..\components\drivers_nrf\rng;..\..\..\..\..\..\..\components\drivers_nrf\rtc;..\..\..\..\..\..\..\components\drivers_nrf\saadc;..\..\..\..\..\..\..\components\drivers_nrf\spi_master;..\..\..\..\..\..\..\components\drivers_nrf\spi_slave;..\..\..\..\..\..\..\components\drivers_nrf\swi;..\..\..\..\..\..\..\components\drivers_nrf\timer;..\..\..\..\..\..\..\components\drivers_nrf\twi_master;..\..\..\..\..\..\..\components\drivers_nrf\twis_slave;..\..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\..\components\drivers_nrf\usbd;..\..\..\..\..\..\..\components\drivers_nrf\wdt;..\..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\..\..\components\libraries\crypto;..\..\..\..\..\..\..\components\libraries\crypto\backend\cc310_lib;..\..\..\..\..\..\..\components\libraries\crypto\backend\micro_ecc;..\..\..\..\..\..\..\components\libraries\crypto\backend\nrf_crypto_sw;..\..\..\..\..\..\..\components\libraries\csense;..\..\..\..\..\..\..\components\libraries\csense_drv;..\..\..\..\..\..\..\components\libraries\ecc;..\..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\..\components\libraries\fds;..\..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\..\..\components\libraries\hardfault;..\..\..\..\..\..\..\components\libraries\hci;..\..\..\..\..\..\..\components\libraries\led_softblink;..\..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\..\components\libraries\low_power_pwm;..\..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\..\components\libraries\pwm;..\..\..\..\..\..\..\components\libraries\queue;..\..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\..\components\libraries\sha256;..\..\..\..\..\..\..\components\libraries\slip;..\..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\..\components\libraries\svc;..\..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\..\components\libraries\twi;..\..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\..\components\libraries\usbd;..\..\..\..\..\..\..\components\libraries\usbd\class\audio;..\..\..\..\..\..\..\components\libraries\usbd\class\cdc;..\..\..\..\..\..\..\components\libraries\usbd\class\cdc\acm;..\..\..\..\..\..\..\components\libraries\usbd\class\hid;..\..\..\..\..\..\..\components\libraries\usbd\class\hid\generic;..\..\..\..\..\..\..\components\libraries\usbd\class\hid\kbd;..\..\..\..\..\..\..\components\libraries\usbd\class\hid\mouse;..\..\..\..\..\..\..\components\libraries\usbd\class\msc;..\..\..\..\..\..\..\components\libraries\usbd\config;..\..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\..\components\softdevice\s140\headers;..\..\..\..\..\..\..\components\softdevice\s140\headers\nrf52;..\..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\..\external\micro-ecc\micro-ecc;..\..\..\..\..\..\..\external\nrf_cc310\include;..\..\..\..\..\..\..\external\segger_rtt;..\config
  asm define: as above
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-DBOARD_PCA10056,-DCONFIG_GPIO_AS_PINRESET,-DNRF52840_XXAA,-DNRF_SD_BLE_API_VERSION=5,-DS140,-DSOFTDEVICE_PRESENT,-DSVC_INTERFACE_CALL_AS_NORMAL_FUNCTION,-DSWI_DISABLE0,-D__HEAP_SIZE=0
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x22000 size 0xde000
  memory RVCT9: RAM 0x20002de8 size 0x3d218
  link misc: --diag_suppress 6330
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../../../components/boards/: boards.c
  group Board Support
    ../../../../../../../components/libraries/bsp/: bsp.c bsp_btn_ble.c bsp_nfc.c
  group nRF_BLE
    ../../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../../../../../../components/ble/ble_advertising/: ble_advertising.c
    ../../../../../../../components/ble/ble_db_discovery/: ble_db_discovery.c
    ../../../../../../../components/ble/peer_manager/: gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c pm_buffer.c pm_mutex.c security_dispatcher.c security_manager.c
    ../../../../../../../components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
  group nRF_BLE_Services
    ../../../../../../../components/ble/ble_services/ble_hrs/: ble_hrs.c
    ../../../../../../../components/ble/ble_services/ble_hrs_c/: ble_hrs_c.c
    ../../../../../../../components/ble/ble_services/ble_rscs/: ble_rscs.c
    ../../../../../../../components/ble/ble_services/ble_rscs_c/: ble_rscs_c.c
  group nRF_Drivers
    ../../../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../../components/drivers_nrf/rng/: nrf_drv_rng.c
    ../../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
  group nRF_Libraries
    ../../../../../../../components/libraries/button/: app_button.c
    ../../../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_mapped_flags.c
    ../../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../../components/libraries/crc16/: crc16.c
    ../../../../../../../components/libraries/fds/: fds.c
    ../../../../../../../components/libraries/fstorage/: fstorage.c
    ../../../../../../../components/libraries/hardfault/: hardfault_implementation.c
    ../../../../../../../components/libraries/mem_manager/: mem_manager.c
    ../../../../../../../components/libraries/queue/: nrf_queue.c
    ../../../../../../../components/libraries/strerror/: nrf_strerror.c
    ../../../../../../../components/libraries/sha256/: sha256.c
  group nRF_Log
    ../../../../../../../components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Segger_RTT
    ../../../../../../../external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group nRF_crypto
    ../../../../../../../components/libraries/crypto/: nrf_crypto_ecdh.c nrf_crypto_ecdsa.c nrf_crypto_hash.c nrf_crypto_init.c nrf_crypto_keys.c nrf_crypto_mem.c nrf_crypto_rng.c
  group nRF_crypto_backend
    ../../../../../../../components/libraries/crypto/backend/cc310_lib/: cc310_lib_ecdh.c cc310_lib_ecdsa.c cc310_lib_hash.c cc310_lib_init.c cc310_lib_keys.c cc310_lib_rng.c cc310_lib_shared.c
    ../../../../../../../components/libraries/crypto/backend/micro_ecc/: micro_ecc_lib_ecdh.c micro_ecc_lib_ecdsa.c micro_ecc_lib_init.c micro_ecc_lib_keys.c micro_ecc_lib_shared.c
    ../../../../../../../components/libraries/crypto/backend/nrf_crypto_sw/: nrf_crypto_sw_hash.c nrf_crypto_sw_rng.c
  group nRF_micro_ecc
    ../../../../../../../external/micro-ecc/nrf52_keil/armgcc/: micro_ecc_lib_nrf52.lib
  group nrf_cc310
    ../../../../../../../external/nrf_cc310/lib/: cc310_keil_0.9.0.lib
target flash_s140_nrf52840_5.0.0-2.alpha_softdevice (ARM-ADS)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: ..
  cpu: as above
  output: s140_nrf52840_5.0.0-2.alpha_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c misc: --reduce_paths
  c include: ..\..\..\config;..\config
  asm misc: --cpreproc_opts=
  asm include: ..\..\..\config;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x22000 size 0xde000
  memory RVCT9: RAM 0x20002de8 size 0x3d218
  link misc: --diag_suppress 6330
software components: CMSIS:CORE 4.3.0, Device:Startup 8.12.0
