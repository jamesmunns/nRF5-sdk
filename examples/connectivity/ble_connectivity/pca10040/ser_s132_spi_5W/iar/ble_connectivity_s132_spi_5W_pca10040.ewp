# IAR project ble_connectivity_s132_spi_5W_pca10040.ewp, settings and files
configuration nrf52832_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52832_xxaa nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BLE_STACK_SUPPORT_REQD; BOARD_PCA10040; BSP_DEFINES_ONLY; CONFIG_GPIO_AS_PINRESET; NRF52; NRF52832_XXAA; NRF52_PAN_12; NRF52_PAN_15; NRF52_PAN_20; NRF52_PAN_31; NRF52_PAN_36; NRF52_PAN_51; NRF52_PAN_54; NRF52_PAN_55; NRF52_PAN_58; NRF52_PAN_64; NRF52_PAN_74; NRF_SD_BLE_API_VERSION=4; S132; SER_CONNECTIVITY; SOFTDEVICE_PRESENT; SWI_DISABLE0; __HEAP_SIZE=1024; __STACK_SIZE=2048
  ICCARM.CCIncludePath2: ..\..\..\config\ble_connectivity_s132_spi_5W_pca10040; ..\..\..\config; ..\..\..\..\..\..\components; ..\..\..\..\..\..\components\ble\ble_dtm; ..\..\..\..\..\..\components\ble\common; ..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\drivers_nrf\clock; ..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\drivers_nrf\spi_slave; ..\..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\..\components\libraries\bsp; ..\..\..\..\..\..\components\libraries\log; ..\..\..\..\..\..\components\libraries\log\src; ..\..\..\..\..\..\components\libraries\scheduler; ..\..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\serialization\common; ..\..\..\..\..\..\components\serialization\common\struct_ser\ble; ..\..\..\..\..\..\components\serialization\common\transport; ..\..\..\..\..\..\components\serialization\common\transport\ser_phy; ..\..\..\..\..\..\components\serialization\common\transport\ser_phy\config; ..\..\..\..\..\..\components\serialization\connectivity; ..\..\..\..\..\..\components\serialization\connectivity\codecs\ble\middleware; ..\..\..\..\..\..\components\serialization\connectivity\codecs\ble\serializers; ..\..\..\..\..\..\components\serialization\connectivity\codecs\common; ..\..\..\..\..\..\components\serialization\connectivity\hal; ..\..\..\..\..\..\components\softdevice\common\softdevice_handler; ..\..\..\..\..\..\components\softdevice\s132\headers; ..\..\..\..\..\..\components\softdevice\s132\headers\nrf52; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..\..\..\..\external\segger_rtt; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ble_connectivity_s132_spi_5W_pca10040.hex
  ILINK.IlinkOutputFile: ble_connectivity_s132_spi_5W_pca10040.out
  ILINK.IlinkIcfFile: ble_connectivity_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Log
    ../../../../../../components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../components/libraries/strerror/: nrf_strerror.c
  group None
    ../../../../../../components/drivers_nrf/spi_slave/: nrf_drv_spis.c
  group Board Definition
    ../../../../../../components/boards/: boards.c
  group nRF_Serialization
    ../../../../../../components/serialization/connectivity/codecs/ble/serializers/: ble_conn.c ble_event_enc.c ble_evt_conn.c ble_gap_conn.c ble_gap_evt_conn.c ble_gattc_conn.c ble_gattc_evt_conn.c ble_gatts_conn.c ble_gatts_evt_conn.c ble_l2cap_conn.c ble_l2cap_evt_conn.c conn_ble_gap_sec_keys.c conn_ble_user_mem.c nrf_soc_conn.c
    ../../../../../../components/serialization/connectivity/codecs/common/: ble_dtm_init.c conn_mw.c conn_mw_nrf_soc.c
    ../../../../../../components/serialization/common/struct_ser/ble/: ble_gap_struct_serialization.c ble_gatt_struct_serialization.c ble_gattc_struct_serialization.c ble_gatts_struct_serialization.c ble_struct_serialization.c nrf_soc_struct_serialization.c
    ../../../../../../components/serialization/common/: ble_serialization.c cond_field_serialization.c ser_dbg_sd_str.c
    ../../../../../../components/serialization/connectivity/codecs/ble/middleware/: conn_mw_ble.c conn_mw_ble_gap.c conn_mw_ble_gattc.c conn_mw_ble_gatts.c conn_mw_ble_l2cap.c
    ../../../../../../components/serialization/connectivity/hal/: dtm_uart.c
    ../../../../../../components/serialization/connectivity/: ser_conn_cmd_decoder.c ser_conn_dtm_cmd_decoder.c ser_conn_error_handling.c ser_conn_event_encoder.c ser_conn_handlers.c ser_conn_pkt_decoder.c ser_conn_reset_cmd_decoder.c
    ../../../../../../components/serialization/common/transport/: ser_hal_transport.c
    ../../../../../../components/serialization/common/transport/ser_phy/: ser_phy_spi_5W_slave.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group nRF_Segger_RTT
    ../../../../../../external/segger_rtt/: RTT_Syscalls_IAR.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_BLE
    ../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../../../../../components/ble/ble_dtm/: ble_dtm.c ble_dtm_hw_nrf52.c
  group Device
    ../../../../../../components/toolchain/iar/: iar_startup_nrf52.s
    ../../../../../../components/toolchain/: system_nrf52.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
