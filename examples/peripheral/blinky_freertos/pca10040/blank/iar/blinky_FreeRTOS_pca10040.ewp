# IAR project blinky_FreeRTOS_pca10040.ewp, settings and files
configuration nrf52832_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52832_xxaa nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD_PCA10040; CONFIG_GPIO_AS_PINRESET; FREERTOS; NRF52; NRF52832_XXAA; NRF52_PAN_12; NRF52_PAN_15; NRF52_PAN_20; NRF52_PAN_31; NRF52_PAN_36; NRF52_PAN_51; NRF52_PAN_54; NRF52_PAN_55; NRF52_PAN_58; NRF52_PAN_64; NRF52_PAN_74
  ICCARM.CCIncludePath2: ..\..\..\config\blinky_FreeRTOS_pca10040; ..\..\..\config; ..\..\..\..\..\..\components; ..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\drivers_nrf\clock; ..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\..\components\libraries\bsp; ..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\components\libraries\log; ..\..\..\..\..\..\components\libraries\log\src; ..\..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..; ..\..\..\..\..\..\external\freertos\config; ..\..\..\..\..\..\external\freertos\portable\CMSIS\nrf52; ..\..\..\..\..\..\external\freertos\portable\IAR\nrf52; ..\..\..\..\..\..\external\freertos\source\include; ..\..\..\..\..\..\external\segger_rtt; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: blinky_FreeRTOS_pca10040.hex
  ILINK.IlinkOutputFile: blinky_FreeRTOS_pca10040.out
  ILINK.IlinkIcfFile: blinky_FreeRTOS_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Log
    ../../../../../../components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group Board Definition
    ../../../../../../components/boards/: boards.c
  group Third Parties
    ../../../../../../external/freertos/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../../external/freertos/source/portable/MemMang/: heap_1.c
    ../../../../../../external/freertos/portable/IAR/nrf52/: port.c
    ../../../../../../external/freertos/portable/CMSIS/nrf52/: port_cmsis.c port_cmsis_systick.c
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../components/libraries/timer/: app_timer_freertos.c
    ../../../../../../components/libraries/strerror/: nrf_strerror.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
  group Board Support
    ../../../../../../components/libraries/bsp/: bsp.c bsp_nfc.c
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group nRF_Segger_RTT
    ../../../../../../external/segger_rtt/: RTT_Syscalls_IAR.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group Device
    ../../../../../../components/toolchain/iar/: iar_startup_nrf52.s
    ../../../../../../components/toolchain/: system_nrf52.c
