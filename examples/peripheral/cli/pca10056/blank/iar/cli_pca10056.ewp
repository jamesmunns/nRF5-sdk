# IAR project cli_pca10056.ewp, settings and files
configuration nrf52840_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52840_xxaa nRF52840_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD_PCA10056; CONFIG_GPIO_AS_PINRESET; DEBUG; DEBUG_NRF; NRF52840_XXAA; SWI_DISABLE0
  ICCARM.CCIncludePath2: ..\..\..\config\cli_pca10056; ..\..\..\config; ..\..\..\..\..\..\components; ..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\drivers_nrf\clock; ..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\..\components\drivers_nrf\power; ..\..\..\..\..\..\components\drivers_nrf\systick; ..\..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\..\components\drivers_nrf\usbd; ..\..\..\..\..\..\components\libraries\atomic; ..\..\..\..\..\..\components\libraries\bsp; ..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\components\libraries\cli; ..\..\..\..\..\..\components\libraries\cli\cdc_acm; ..\..\..\..\..\..\components\libraries\cli\rtt; ..\..\..\..\..\..\components\libraries\cli\uart; ..\..\..\..\..\..\components\libraries\fifo; ..\..\..\..\..\..\components\libraries\hardfault; ..\..\..\..\..\..\components\libraries\hardfault\nrf52; ..\..\..\..\..\..\components\libraries\log; ..\..\..\..\..\..\components\libraries\log\src; ..\..\..\..\..\..\components\libraries\queue; ..\..\..\..\..\..\components\libraries\scheduler; ..\..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\..\components\libraries\usbd; ..\..\..\..\..\..\components\libraries\usbd\class\cdc; ..\..\..\..\..\..\components\libraries\usbd\class\cdc\acm; ..\..\..\..\..\..\components\libraries\usbd\config; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..; ..\..\..\..\..\..\external\segger_rtt; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: cli_pca10056.hex
  ILINK.IlinkOutputFile: cli_pca10056.out
  ILINK.IlinkIcfFile: cli_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Log
    ../../../../../../components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group Board Definition
    ../../../../../../components/boards/: boards.c
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../components/libraries/uart/: app_uart_fifo.c
    ../../../../../../components/libraries/usbd/class/cdc/acm/: app_usbd_cdc_acm.c
    ../../../../../../components/libraries/hardfault/nrf52/handler/: hardfault_handler_iar.c
    ../../../../../../components/libraries/hardfault/: hardfault_implementation.c
    ../../../../../../components/libraries/cli/: nrf_cli.c
    ../../../../../../components/libraries/cli/cdc_acm/: nrf_cli_cdc_acm.c
    ../../../../../../components/libraries/cli/rtt/: nrf_cli_rtt.c
    ../../../../../../components/libraries/cli/uart/: nrf_cli_uart.c
    ../../../../../../components/libraries/queue/: nrf_queue.c
    ../../../../../../components/libraries/strerror/: nrf_strerror.c
  group nRF_Drivers
    ../../../../../../components/libraries/usbd/: app_usbd.c app_usbd_core.c app_usbd_string_desc.c
    ../../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/power/: nrf_drv_power.c
    ../../../../../../components/drivers_nrf/systick/: nrf_drv_systick.c
    ../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../../components/drivers_nrf/usbd/: nrf_drv_usbd.c
    ../../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
  group Board Support
    ../../../../../../components/libraries/bsp/: bsp.c bsp_nfc.c
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group nRF_Segger_RTT
    ../../../../../../external/segger_rtt/: RTT_Syscalls_IAR.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group Device
    ../../../../../../components/toolchain/iar/: iar_startup_nrf52840.s
    ../../../../../../components/toolchain/: system_nrf52840.c
