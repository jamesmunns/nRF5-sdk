# IAR project ram_retention_pca10056.ewp, settings and files
configuration nrf52840_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52840_xxaa nRF52840_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD_PCA10056; BSP_DEFINES_ONLY; CONFIG_GPIO_AS_PINRESET; NRF52840_XXAA
  ICCARM.CCIncludePath2: ..\..\..\config\ram_retention_pca10056; ..\..\..\config; ..\..\..\..\..\..\components; ..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\..\components\libraries\bsp; ..\..\..\..\..\..\components\libraries\log; ..\..\..\..\..\..\components\libraries\log\src; ..\..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ram_retention_pca10056.hex
  ILINK.IlinkOutputFile: ram_retention_pca10056.out
  ILINK.IlinkIcfFile: ram_retention_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Device
    ../../../../../../components/toolchain/iar/: iar_startup_nrf52840.s
    ../../../../../../components/toolchain/: system_nrf52840.c
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../../components/boards/: boards.c
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c app_error_weak.c
    ../../../../../../components/libraries/strerror/: nrf_strerror.c
