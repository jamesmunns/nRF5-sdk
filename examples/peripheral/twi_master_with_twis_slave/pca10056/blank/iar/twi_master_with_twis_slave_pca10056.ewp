# IAR project twi_master_with_twis_slave_pca10056.ewp, settings and files
configuration nrf52840_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52840_xxaa nRF52840_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD_PCA10056; CONFIG_GPIO_AS_PINRESET; DEBUG_NRF; NRF52840_XXAA; SWI_DISABLE0
  ICCARM.CCIncludePath2: ..\..\..\config\twi_master_with_twis_slave_pca10056; ..\..\..\config; ..\..\..\..\..\..\components; ..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\..\components\drivers_nrf\twi_master; ..\..\..\..\..\..\components\drivers_nrf\twis_slave; ..\..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\..\components\libraries\bsp; ..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\components\libraries\fifo; ..\..\..\..\..\..\components\libraries\log; ..\..\..\..\..\..\components\libraries\log\src; ..\..\..\..\..\..\components\libraries\scheduler; ..\..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..; ..\..\..\..\..\..\external\segger_rtt; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: twi_master_with_twis_slave_pca10056.hex
  ILINK.IlinkOutputFile: twi_master_with_twis_slave_pca10056.out
  ILINK.IlinkIcfFile: twi_master_with_twis_slave_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Log
    ../../../../../../components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group Board Definition
    ../../../../../../components/boards/: boards.c
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../components/libraries/uart/: app_uart_fifo.c retarget.c
    ../../../../../../components/libraries/strerror/: nrf_strerror.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/twi_master/: nrf_drv_twi.c
    ../../../../../../components/drivers_nrf/twis_slave/: nrf_drv_twis.c
    ../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
  group Board Support
    ../../../../../../components/libraries/bsp/: bsp.c bsp_nfc.c
  group Application
    ../../../: eeprom_simulator.c main.c
    ../config/: sdk_config.h
  group nRF_Segger_RTT
    ../../../../../../external/segger_rtt/: RTT_Syscalls_IAR.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group Device
    ../../../../../../components/toolchain/iar/: iar_startup_nrf52840.s
    ../../../../../../components/toolchain/: system_nrf52840.c
